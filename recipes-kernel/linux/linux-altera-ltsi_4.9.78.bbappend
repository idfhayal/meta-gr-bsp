KERNEL_REPO_gr-soc = "git://github.com/shalex88/linux-socfpga.git"
