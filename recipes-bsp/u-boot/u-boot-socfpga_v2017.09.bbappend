# SRC_URI_gr-soc = "git://github.com/shalex88/uboot.git;branch=develop;prot=https"
SRC_URI_gr-soc = "git:///media/alex/Develop/Projects/BSP/altera/uboot;branch=develop;prot=file"
SRCREV = "${AUTOREV}"
# SRC_URI[md5sum] = "???"
